Commit message: Add sphere collider

File: test/data/simple_mechanism.urdf (robot description, URDF)
Before this commit: robot simple_mechanism, 4 links, 3 joints
Links:
- link cone1: geometry collision sphere center=0 0 0 radius=0.1
